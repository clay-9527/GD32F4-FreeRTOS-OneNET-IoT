# Keil uVision project GD32F470.uvprojx, settings and files
target GD32F470 (5060960::V5.06 update 7 (build 960)::.\Version5.6)
  device: GD32F470ZG GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.2.0
  cpu: IRAM(0x20000000,0x070000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x0100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: GD32F470 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\Firmware\GD32F4xx_standard_peripheral\Include;..\Firmware\CMSIS;..\Firmware\CMSIS\GD\GD32F4xx\Include;..\User;..\Hardware\led;..\Hardware\usart;..\Hardware\key;..\FreeRTOS\portable\RVDS\ARM_CM4F;..\FreeRTOS\portable;..\FreeRTOS\include;..\OneNET
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x70000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: main.c gd32f4xx_it.c FreeRTOSConfig.h FreeRTOS_TASK.c
  group CMSIS
    ../Firmware/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
    ../Firmware/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f450_470.s
  group Hardware
    ../Hardware/led/: bsp_led.c
    ../Hardware/usart/: bsp_usart.c
    ../Hardware/key/: bsp_key.c
  group Firmware
    ../Firmware/GD32F4xx_standard_peripheral/Source/: gd32f4xx_gpio.c gd32f4xx_rcu.c gd32f4xx_usart.c
  group FreeRTOS_Source
    ../FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group “FreeRTOS_Portable
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
  group OneNET
    ../OneNET/: base64.c cJSON.c esp8266.c hmac_sha1.c MqttKit.c onenet.c SDK使用说明.txt
